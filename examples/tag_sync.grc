<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_size</value></param>
<param><key>value</key><value>16</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>interval_size</value></param>
<param><key>value</key><value>pkt_interval * fft_size</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pd_len</value></param>
<param><key>value</key><value>197</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pkt_interval</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pkt_size</value></param>
<param><key>value</key><value>fft_size * (1 + tx + pd_len)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sync_word</value></param>
<param><key>value</key><value>[0, 0, 0, 0, 1, -1, -1, 1, 0, 1, -1, -1, 1, 0, 0, 0]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>thr</value></param>
<param><key>value</key><value>1e-7</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>beamnet_energy_detector</key>
<param><key>id</key><value>beamnet_energy_detector_0</value></param>
<param><key>pkt_size</key><value>fft_size</value></param>
</block>
<block>
<key>beamnet_packet_extraction</key>
<param><key>id</key><value>beamnet_packet_extraction_0</value></param>
<param><key>fft_size</key><value>fft_size</value></param>
<param><key>pkt_size</key><value>pkt_size + interval_size</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>thr</key><value>thr</value></param>
</block>
<block>
<key>beamnet_symbol_sync</key>
<param><key>id</key><value>beamnet_symbol_sync_0</value></param>
<param><key>fft_size</key><value>fft_size</value></param>
<param><key>sync_word</key><value>np.fft.ifft(np.fft.fftshift(sync_word))</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>/home/shiyue_deep/Projects/gr-beamnet/apps/debug_sync_nrg.bin</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_1</value></param>
<param><key>file</key><value>/home/shiyue_deep/Projects/gr-beamnet/apps/debug_sync_symbol.bin</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_2</value></param>
<param><key>file</key><value>/home/shiyue_deep/Projects/gr-beamnet/apps/debug_tag_pkt.bin</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/home/shiyue_deep/Projects/gr-beamnet/apps/debug_tag_reflection.bin</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<connection><source_block_id>beamnet_energy_detector_0</source_block_id><sink_block_id>beamnet_packet_extraction_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>beamnet_energy_detector_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>beamnet_packet_extraction_0</source_block_id><sink_block_id>blocks_file_sink_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>beamnet_symbol_sync_0</source_block_id><sink_block_id>beamnet_packet_extraction_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>beamnet_symbol_sync_0</source_block_id><sink_block_id>blocks_file_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>beamnet_energy_detector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>beamnet_packet_extraction_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>beamnet_symbol_sync_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
