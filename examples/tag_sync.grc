<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_size</value></param>
<param><key>value</key><value>16</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sym_pd</value></param>
<param><key>value</key><value>195</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sym_pkt</value></param>
<param><key>value</key><value>sym_sync + tx + sym_pd</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sym_sync</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sync_word</value></param>
<param><key>value</key><value>(0, 0, -0.7485-0.6631j, 0.8855+0.4647j, 0.5681-0.8230j, 0.8855-0.4647j, -0.3546+0.9350j, 1, 0, -0.3546+0.9350j, 0.8855-0.4647j, 0.5681-0.8230j, 0.8855+0.4647j, -0.7485-0.6631j, -0.9709+0.2393j, 0)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tag</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>thr</value></param>
<param><key>value</key><value>1e-7</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>win_size</value></param>
<param><key>value</key><value>320</value></param>
</block>
<block>
<key>beamnet_energy_detector</key>
<param><key>id</key><value>beamnet_energy_detector_0</value></param>
<param><key>win_size</key><value>win_size</value></param>
</block>
<block>
<key>beamnet_packet_demux</key>
<param><key>id</key><value>beamnet_packet_demux_0</value></param>
<param><key>fft_size</key><value>fft_size</value></param>
<param><key>sym_pd</key><value>sym_pd</value></param>
<param><key>sym_sync</key><value>sym_sync</value></param>
<param><key>tx</key><value>tx</value></param>
</block>
<block>
<key>beamnet_packet_extraction</key>
<param><key>id</key><value>beamnet_packet_extraction_0</value></param>
<param><key>detect_size</key><value>win_size + sym_pkt * fft_size</value></param>
<param><key>fft_size</key><value>fft_size</value></param>
<param><key>inr</key><value>0.1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sym_pkt</key><value>sym_pkt</value></param>
<param><key>thr</key><value>thr</value></param>
</block>
<block>
<key>beamnet_phase_alignment</key>
<param><key>id</key><value>beamnet_phase_alignment_0</value></param>
<param><key>fft_size</key><value>fft_size</value></param>
<param><key>Nloop</key><value>1000</value></param>
<param><key>tx</key><value>tx</value></param>
<param><key>tag</key><value>tag</value></param>
</block>
<block>
<key>beamnet_symbol_sync</key>
<param><key>id</key><value>beamnet_symbol_sync_0</value></param>
<param><key>sym_sync</key><value>sym_sync</value></param>
<param><key>sync_word</key><value>np.fft.ifft(np.fft.fftshift(sync_word))</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>/home/shiyue_deep/Projects/gr-beamnet/apps/debug_sync_nrg.bin</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_1</value></param>
<param><key>file</key><value>/home/shiyue_deep/Projects/gr-beamnet/apps/debug_sync_symbol.bin</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_2</value></param>
<param><key>file</key><value>/home/shiyue_deep/Projects/gr-beamnet/apps/debug_tag_pkt.bin</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>fft_size</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/home/shiyue_deep/Projects/gr-beamnet/apps/debug_tag_reflection.bin</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<connection><source_block_id>beamnet_energy_detector_0</source_block_id><sink_block_id>beamnet_packet_extraction_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>beamnet_energy_detector_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>beamnet_packet_demux_0</source_block_id><sink_block_id>beamnet_phase_alignment_0</sink_block_id><source_key>ce</source_key><sink_key>ce</sink_key></connection>
<connection><source_block_id>beamnet_packet_extraction_0</source_block_id><sink_block_id>beamnet_packet_demux_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>beamnet_packet_extraction_0</source_block_id><sink_block_id>blocks_file_sink_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>beamnet_symbol_sync_0</source_block_id><sink_block_id>beamnet_packet_extraction_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>beamnet_symbol_sync_0</source_block_id><sink_block_id>blocks_file_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>beamnet_energy_detector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>beamnet_packet_extraction_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>beamnet_symbol_sync_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
