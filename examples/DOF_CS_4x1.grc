<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_freq_rx</value></param>
<param><key>value</key><value>919e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_freq_tx</value></param>
<param><key>value</key><value>915e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_size</value></param>
<param><key>value</key><value>16</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>power_gain_rx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>power_gain_tx</value></param>
<param><key>value</key><value>60</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sig_coeff</value></param>
<param><key>value</key><value>0.5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sym_pd</value></param>
<param><key>value</key><value>194</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sym_pkt</value></param>
<param><key>value</key><value>sym_sync + tx + sym_pd</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sym_sync</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sync_word</value></param>
<param><key>value</key><value>(0, 0, -0.7485-0.6631j, 0.8855+0.4647j, 0.5681-0.8230j, 0.8855-0.4647j, -0.3546+0.9350j, 1, 0, -0.3546+0.9350j, 0.8855-0.4647j, 0.5681-0.8230j, 0.8855+0.4647j, -0.7485-0.6631j, -0.9709+0.2393j, 0)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tag</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>thr</value></param>
<param><key>value</key><value>1e-7</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>win_size</value></param>
<param><key>value</key><value>320</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>work_mode</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>beamnet_energy_detector</key>
<param><key>id</key><value>beamnet_energy_detector_0</value></param>
<param><key>win_size</key><value>win_size</value></param>
</block>
<block>
<key>beamnet_packet_demux</key>
<param><key>id</key><value>beamnet_packet_demux_0</value></param>
<param><key>fft_size</key><value>fft_size</value></param>
<param><key>sym_pd</key><value>sym_pd</value></param>
<param><key>sym_sync</key><value>sym_sync</value></param>
<param><key>tx</key><value>tx</value></param>
</block>
<block>
<key>beamnet_packet_extraction</key>
<param><key>id</key><value>beamnet_packet_extraction_0</value></param>
<param><key>detect_size</key><value>win_size + sym_pkt * fft_size</value></param>
<param><key>fft_size</key><value>fft_size</value></param>
<param><key>inr</key><value>0.1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sym_pkt</key><value>sym_pkt</value></param>
<param><key>thr</key><value>thr</value></param>
</block>
<block>
<key>beamnet_source_signal</key>
<param><key>id</key><value>beamnet_source_signal_0</value></param>
<param><key>fft_size</key><value>fft_size</value></param>
<param><key>index</key><value>0</value></param>
<param><key>mode</key><value>work_mode</value></param>
<param><key>sym_pd</key><value>sym_pd</value></param>
<param><key>sym_sync</key><value>sym_sync</value></param>
<param><key>sync_word</key><value>sync_word</value></param>
<param><key>tx</key><value>tx</value></param>
</block>
<block>
<key>beamnet_source_signal</key>
<param><key>id</key><value>beamnet_source_signal_1</value></param>
<param><key>fft_size</key><value>fft_size</value></param>
<param><key>index</key><value>1</value></param>
<param><key>mode</key><value>work_mode</value></param>
<param><key>sym_pd</key><value>sym_pd</value></param>
<param><key>sym_sync</key><value>sym_sync</value></param>
<param><key>sync_word</key><value>sync_word</value></param>
<param><key>tx</key><value>tx</value></param>
</block>
<block>
<key>beamnet_source_signal</key>
<param><key>id</key><value>beamnet_source_signal_2</value></param>
<param><key>fft_size</key><value>fft_size</value></param>
<param><key>index</key><value>2</value></param>
<param><key>mode</key><value>work_mode</value></param>
<param><key>sym_pd</key><value>sym_pd</value></param>
<param><key>sym_sync</key><value>sym_sync</value></param>
<param><key>sync_word</key><value>sync_word</value></param>
<param><key>tx</key><value>tx</value></param>
</block>
<block>
<key>beamnet_source_signal</key>
<param><key>id</key><value>beamnet_source_signal_3</value></param>
<param><key>fft_size</key><value>fft_size</value></param>
<param><key>index</key><value>3</value></param>
<param><key>mode</key><value>work_mode</value></param>
<param><key>sym_pd</key><value>sym_pd</value></param>
<param><key>sym_sync</key><value>sym_sync</value></param>
<param><key>sync_word</key><value>sync_word</value></param>
<param><key>tx</key><value>tx</value></param>
</block>
<block>
<key>beamnet_symbol_sync</key>
<param><key>id</key><value>beamnet_symbol_sync_0</value></param>
<param><key>sym_sync</key><value>sym_sync</value></param>
<param><key>sync_word</key><value>np.fft.ifft(np.fft.fftshift(sync_word))</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>/home/shiyue_deep/Projects/gr-beamnet/apps/debug_tag_reflection.bin</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_1</value></param>
<param><key>file</key><value>/home/shiyue_deep/Projects/gr-beamnet/apps/debug_sync_nrg.bin</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_2</value></param>
<param><key>file</key><value>/home/shiyue_deep/Projects/gr-beamnet/apps/debug_sync_symbol.bin</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_3</value></param>
<param><key>file</key><value>/home/shiyue_deep/Projects/gr-beamnet/apps/debug_tag_pkt.bin</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>fft_size</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>sig_coeff</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1</value></param>
<param><key>const</key><value>sig_coeff</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_2</value></param>
<param><key>const</key><value>sig_coeff</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_3</value></param>
<param><key>const</key><value>sig_coeff</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>fft_size</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>fft_size</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_2</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>fft_size</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_3</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>fft_size</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>reverse_fft_vxx_0</value></param>
<param><key>fft_size</key><value>fft_size</value></param>
<param><key>forward</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value>()</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>reverse_fft_vxx_1</value></param>
<param><key>fft_size</key><value>fft_size</value></param>
<param><key>forward</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value>()</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>reverse_fft_vxx_2</value></param>
<param><key>fft_size</key><value>fft_size</value></param>
<param><key>forward</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value>()</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>reverse_fft_vxx_3</value></param>
<param><key>fft_size</key><value>fft_size</value></param>
<param><key>forward</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value>()</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>bw0</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>center_freq_tx</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>power_gain_tx</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>"serial=320F337"</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>clock_source0</key><value>external</value></param>
<param><key>sd_spec0</key><value>A:A</value></param>
<param><key>time_source0</key><value>external</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_1</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>bw0</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>center_freq_tx</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>power_gain_tx</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>"serial=320F33C"</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>clock_source0</key><value>external</value></param>
<param><key>sd_spec0</key><value>A:A</value></param>
<param><key>time_source0</key><value>external</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_2</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>bw0</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>center_freq_tx</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>power_gain_tx</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>"serial=30FDE1D"</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>clock_source0</key><value>external</value></param>
<param><key>sd_spec0</key><value>A:A</value></param>
<param><key>time_source0</key><value>external</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_3</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>bw0</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>center_freq_tx</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>power_gain_tx</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>"serial=30FDE5E"</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>clock_source0</key><value>external</value></param>
<param><key>sd_spec0</key><value>A:A</value></param>
<param><key>time_source0</key><value>external</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>bw0</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>center_freq_rx</value></param>
<param><key>dc_offs_enb0</key><value>True</value></param>
<param><key>iq_imbal_enb0</key><value>True</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>0</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>"serial=320F337"</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>clock_source0</key><value>external</value></param>
<param><key>sd_spec0</key><value>A:A</value></param>
<param><key>time_source0</key><value>external</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value>sync</value></param>
</block>
<connection><source_block_id>beamnet_energy_detector_0</source_block_id><sink_block_id>beamnet_packet_extraction_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>beamnet_energy_detector_0</source_block_id><sink_block_id>blocks_file_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>beamnet_packet_extraction_0</source_block_id><sink_block_id>beamnet_packet_demux_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>beamnet_packet_extraction_0</source_block_id><sink_block_id>blocks_file_sink_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>beamnet_source_signal_0</source_block_id><sink_block_id>reverse_fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>beamnet_source_signal_1</source_block_id><sink_block_id>reverse_fft_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>beamnet_source_signal_2</source_block_id><sink_block_id>reverse_fft_vxx_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>beamnet_source_signal_3</source_block_id><sink_block_id>reverse_fft_vxx_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>beamnet_symbol_sync_0</source_block_id><sink_block_id>beamnet_packet_extraction_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>beamnet_symbol_sync_0</source_block_id><sink_block_id>blocks_file_sink_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>uhd_usrp_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_2</source_block_id><sink_block_id>uhd_usrp_sink_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_3</source_block_id><sink_block_id>uhd_usrp_sink_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_1</source_block_id><sink_block_id>blocks_multiply_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_2</source_block_id><sink_block_id>blocks_multiply_const_vxx_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_3</source_block_id><sink_block_id>blocks_multiply_const_vxx_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>reverse_fft_vxx_0</source_block_id><sink_block_id>blocks_vector_to_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>reverse_fft_vxx_1</source_block_id><sink_block_id>blocks_vector_to_stream_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>reverse_fft_vxx_2</source_block_id><sink_block_id>blocks_vector_to_stream_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>reverse_fft_vxx_3</source_block_id><sink_block_id>blocks_vector_to_stream_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>beamnet_energy_detector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>beamnet_packet_extraction_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>beamnet_symbol_sync_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
