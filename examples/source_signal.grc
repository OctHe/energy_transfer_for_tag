<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_size</value></param>
<param><key>value</key><value>16</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pd_len</value></param>
<param><key>value</key><value>197</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pkt_interval</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sync_word</value></param>
<param><key>value</key><value>[0, 0, 0, 0, 1, -1, -1, 1, 0, 1, -1, -1, 1, 0, 0, 0]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tx</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>beamnet_source_signal</key>
<param><key>id</key><value>beamnet_source_signal_0</value></param>
<param><key>baseline</key><value>0</value></param>
<param><key>fft_size</key><value>fft_size</value></param>
<param><key>index</key><value>0</value></param>
<param><key>null_len</key><value>pkt_interval</value></param>
<param><key>pd_len</key><value>pd_len</value></param>
<param><key>sync_word</key><value>sync_word</value></param>
<param><key>tx</key><value>2</value></param>
</block>
<block>
<key>beamnet_source_signal</key>
<param><key>id</key><value>beamnet_source_signal_1</value></param>
<param><key>baseline</key><value>0</value></param>
<param><key>fft_size</key><value>fft_size</value></param>
<param><key>index</key><value>1</value></param>
<param><key>null_len</key><value>pkt_interval</value></param>
<param><key>pd_len</key><value>pd_len</value></param>
<param><key>sync_word</key><value>sync_word</value></param>
<param><key>tx</key><value>2</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>/home/shiyue_deep/Projects/gr-beamnet/apps/debug_source_signal_tx0.bin</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>fft_size</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0</value></param>
<param><key>file</key><value>/home/shiyue_deep/Projects/gr-beamnet/apps/debug_source_signal_tx1.bin</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>fft_size</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>fft_size</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>fft_size</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<block>
<key>qtgui_edit_box_msg</key>
<param><key>id</key><value>qtgui_edit_box_msg_0</value></param>
<param><key>key</key><value>()</value></param>
<param><key>type</key><value>flt_vec</value></param>
<param><key>value</key><value>0, 0.0</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>reverse_fft_vxx_1</value></param>
<param><key>fft_size</key><value>fft_size</value></param>
<param><key>forward</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value>()</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>reverse_fft_vxx_1_0</value></param>
<param><key>fft_size</key><value>fft_size</value></param>
<param><key>forward</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value>()</value></param>
</block>
<connection><source_block_id>beamnet_source_signal_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>beamnet_source_signal_1</source_block_id><sink_block_id>blocks_throttle_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>reverse_fft_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_0</source_block_id><sink_block_id>reverse_fft_vxx_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>qtgui_edit_box_msg_0</source_block_id><sink_block_id>beamnet_source_signal_1</sink_block_id><source_key>msg</source_key><sink_key>phase</sink_key></connection>
<connection><source_block_id>reverse_fft_vxx_1</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>reverse_fft_vxx_1_0</source_block_id><sink_block_id>blocks_file_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
