<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Np</value></param>
<param><key>value</key><value>200</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Ntx</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>amp</value></param>
<param><key>value</key><value>0.2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bw</value></param>
<param><key>value</key><value>2e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>value</key><value>915e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_size</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gain</value></param>
<param><key>value</key><value>68</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>master_signal</value></param>
<param><key>value</key><value>(0, 0, 0, 0, 1, 0, 1, 0, 0, 0)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>slave_signal_1</value></param>
<param><key>value</key><value>(0, 0, 0, 1, 0, 0, 0, 1, 0, 0)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>slave_signal_2</value></param>
<param><key>value</key><value>(0, 0, 1, 0, 0, 0, 0, 0, 1, 0)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>slave_signal_3</value></param>
<param><key>value</key><value>(0, 1, 0, 0, 0, 0, 0, 0, 0, 1)</value></param>
</block>
<block>
<key>beamnet_time_and_freq_offset_estimation</key>
<param><key>id</key><value>beamnet_time_and_freq_offset_estimation_0</value></param>
<param><key>fft_size</key><value>fft_size</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>tx</key><value>Ntx</value></param>
<param><key>update_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/home/shiyue_deep/Projects/BeamNet/gr-beamnet/apps/debug_TX_sync_f.bin</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
<param><key>vlen</key><value>fft_size</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>fft_size</value></param>
</block>
<connection><source_block_id>beamnet_time_and_freq_offset_estimation_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>freq_sync</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>beamnet_time_and_freq_offset_estimation_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
